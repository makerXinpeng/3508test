# Keil uVision project DJI_3510Demo.uvprojx, settings and files
target RM2018_Ambition (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2018_Ambition
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER
  c include: .\Control;.\GetData;.\Main;.\STlibrary\inc;.\STlibrary\core;.\System\delay;.\System\sys;.\System\usart;.\Status;.\System\can;.\MPU6050;.\GetData\eMPL;.\GetData\IIC;.\GetData\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STlibrary
    ./STlibrary/src/: stm32f4xx_wwdg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_sai.c stm32f4xx_rtc.c stm32f4xx_rng.c stm32f4xx_rcc.c stm32f4xx_pwr.c stm32f4xx_ltdc.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_hash_sha1.c stm32f4xx_hash_md5.c stm32f4xx_hash.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_dcmi.c stm32f4xx_dbgmcu.c stm32f4xx_dac.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_aes.c stm32f4xx_cryp.c stm32f4xx_crc.c stm32f4xx_can.c stm32f4xx_adc.c misc.c
    ./STlibrary/core/: startup_stm32f427x.s
  group Symtem
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/can/: can.c
  group Control
    ./GetData/: Control_Task.c
    ./Control/: ChassisMotor.c
  group GetData
    ./GetData/: remote.c Encoder.c
  group Main
    ./Main/: main.c stm32f4xx_it.c system_stm32f4xx.c
